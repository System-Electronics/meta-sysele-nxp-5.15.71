# Override the branch to use "main" instead of "master"
SRC_URI = "git://github.com/intel/${BPN};branch=main;protocol=https"
