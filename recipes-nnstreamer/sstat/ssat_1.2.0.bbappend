#Force to this git repository
SRC_URI = "git://github.com/myungjoo/SSAT.git;branch=main;protocol=https"
