DESCRIPTION = "Secure Boot image: system-astrial-image"

require system-astrial-image.bb

inherit secure-boot-image
