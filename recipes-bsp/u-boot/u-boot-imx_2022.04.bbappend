#
# Copyright (C)2024 KOAN sas - <https://koansoftware.com>
#

# change the NXP repo with the System Electronics custom one
UBOOT_SRC = "git://github.com/System-Electronics/uboot-imx-lf-5.15.71;protocol=https"
SRCBRANCH = "main"
SRCREV = "ebe09f64fac408bf46b87c8a62cab7f363c8a2bf"

# set local version
LOCALVERSION = "-sysele"
