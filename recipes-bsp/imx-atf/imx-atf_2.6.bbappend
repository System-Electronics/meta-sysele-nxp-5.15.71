#
# Copyright (C)2024 KOAN sas - <https://koansoftware.com>
#

# change the NXP repo with the System Electronics custom one
ATF_SRC = "git://github.com/System-Electronics/imx-atf-lf-5.15.71;protocol=https"
SRCBRANCH = "main"
SRCREV = "66574a3900280de6d4b013c13d0402ea6a24d82f"
