# see https://github.com/Freescale/meta-freescale/commit/4375edbb9da1eb18a46b30a29d2574f06b331a88
# meta-imx still hasn't updated its recipe for kirkstone
UUU_BOOTLOADER_UNTAGGED = "${BOOT_NAME}-untagged"
